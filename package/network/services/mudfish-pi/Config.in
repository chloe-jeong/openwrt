## package/network/services/mudfish-pi/Config.in
```kconfig
if PACKAGE_mudfish-pi

config MUDFISH_ENABLE_PF
	bool "Enable internal packet filter"
	default y

endif
```
